Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2015-07-30T16:39:29
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.12.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Jul 30 16:39:29 2015* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{1F86F5A9-A53E-48A8-9E02-5738B13C9193}\ifc* Database version: 5507* Database creation date: Thu Jul 30 16:39:27 2015* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Jul 30 16:39:28 2015* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Jul 30 16:39:28 2015* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: NBS_PineappleContracts_DomesticChairs_BossChair, NBS_PineappleContracts_DmstcChrs_BossChair:NBS_PineappleContracts_DomesticChairs_BossChair:279586
In: Level 0
Type - Classification: Pr_40_50_12_22 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_BossChair; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/exyrjqip; NBSDescription: Domestic chairs; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-20/365; NBSTypeID: n/a; ProductInformation: www.pineapplecontracts.com/userfiles/file/Pineapple-main-brochure-2014.pdf; Revision: n/a; Version: 2; Uniclass2015Title: Dining chairs; Uniclass2015Code: Pr_40_50_12_22; Uniclass2015Version: Products v1.5
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_50_12_22:Dining chairs; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Curved braces between back leg and seat, substantial timbers in back, corner braces under seat; Finish: n/a; Grade: n/a; Manufacturer: www.pineapplecontracts.com; Material: n/a; ModelNumber: 1BS1-001; ModelReference: Boss Chair; Name: DomesticChairs_BossChair_PineappleContracts; NominalWidth: 460 mm; ReplacementCost: n/a; Shape: n/a; Size: 880 x 460 x 550 mm; SustainabilityPerformance: n/a; WarrantyDescription: Guarantee against manufacturing faults; WarrantyDurationLabor: n/a; WarrantyDurationParts: 7; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_FurnitureTypeCommon - Description: Wooden seat; IsBuiltIn: no; MainColor: Natural; NominalDepth: 550 mm; NominalHeight: 880 mm; NominalLength: 0 mm
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 0 mm; LowestSeatingHeight: 0 mm; SeatingHeight: 460 mm
Type - NBS_Data - ArmOptions: With arms, Without arms; EnvironmentalProductDeclaration: n/a; FabricFireRating: Source 5 (all fabrics); FootOptions: Legs, Skis; SeatFabricOptions: A wide choice of fabrics are available; SeatMaterialOptions: 25 mm thick solid wood, Fabric; SideOptions: Open (standard), Filled; StrengthAndStability: Level 2; UndershelfOptions: Not required, Timber
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
